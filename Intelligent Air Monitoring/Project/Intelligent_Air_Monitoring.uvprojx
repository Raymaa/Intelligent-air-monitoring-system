# Keil uVision project Intelligent_Air_Monitoring.uvprojx, settings and files
target Intelligent_Air_Monitoring (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Intelligent_Air_Monitoring +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\usart;..\User\led;..\User\SysTick;..\User\dht11;..\User\lcd;..\User\flash;..\User\adc;..\User\beep;..\User\Common;..\User\esp8266;..\User\Upload;..\User\GeneralTim;..\User\cJSON;..\User\bsp_fan
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/usart/: usart.c
    ../User/led/: led.c
    ../User/SysTick/: systick.c
    ../User/dht11/: dht11.c
    ../User/lcd/: fonts.c ili9341_lcd.c
    ../User/flash/: bsp_spi_flash.c
    ../User/adc/: adc.c
    ../User/beep/: beep.c
    ../User/Common/: common.c
    ../User/esp8266/: bsp_esp8266.c
    ../User/Upload/: upload.c
    ../User/GeneralTim/: bsp_GeneralTim.c
    ../User/cJSON/: cJSON.c
    ../User/bsp_fan/: bsp_fan.c
  group STARTUP
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group DOC
    ../Doc/: readme.txt
  group FWLB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
